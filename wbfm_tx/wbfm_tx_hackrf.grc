<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>wbfm_tx_hackrf</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>lengths</key><value>1, 1</value></param>
</block>
<block>
<key>analog_wfm_tx</key>
<param><key>id</key><value>analog_wfm_tx_0</value></param>
<param><key>audio_rate</key><value>32000</value></param>
<param><key>quad_rate</key><value>320000</value></param>
<param><key>tau</key><value>300e-6</value></param>
<param><key>max_dev</key><value>75e3</value></param>
</block>
<block>
<key>fractional_interpolator_xx</key>
<param><key>id</key><value>fractional_interpolator_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>phase_shift</key><value>1</value></param>
<param><key>interp_ratio</key><value>875e-3</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/scateu/hackrf/grcs/WBFM_TX/jen_ai_marre.wav</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>nchan</key><value>2</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate*4</value></param>
<param><key>freq0</key><value>93e6</value></param>
<param><key>corr0</key><value>26</value></param>
<param><key>gain0</key><value>14</value></param>
<param><key>if_gain0</key><value>40</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>250e3</value></param>
</block>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>fractional_interpolator_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_tx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_interpolator_xx_0</source_block_id><sink_block_id>analog_wfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
